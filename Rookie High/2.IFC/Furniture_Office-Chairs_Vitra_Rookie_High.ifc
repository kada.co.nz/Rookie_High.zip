Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-09-13T12:38:02
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Sep 13 12:38:02 2019 * Host: Avocado-PC * Database: C:\Users\Avocado\AppData\Local\Temp\{419A2112-1CAA-4561-AEA4-DD71B58ED2BF}\ifc * Database version: 5507 * Database creation date: Fri Sep 13 12:38:01 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Sep 13 12:38:02 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Sep 13 12:38:02 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Rookie High, Furniture_Office-Chairs_Vitra_Rookie_High:Rookie High:388128
In: Level 1
Type - Material: Stainless Steel, Basic dark, 53 soft grey, Sierra grey 19
Type - Dimensions(Type) - NominalDepth: 710 mm; NominalLength: 710 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: Furniture_Office-Chairs_Vitra_Rookie_High; ConvergoRefNr: 0089-1909-0019-CH; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Office chairs; NBSReference: 45-35-20/330; ProductInformation: Rookie High translates the advantages of the Rookie office chair to standing table height. Pleasantly comfortable, it adapts quickly and easily to each user with the aid of minimal elements and functions.; Revision: n/a; Uniclass2: Pr_40_50_12_57; Uniclass2015Description: Office chairs; Uniclass2015Reference: Pr_40_50_12_57; Version: 1; VersionDate: 10/09/2019
Type - Identity Data(Type) - Collection: Rookie; Cost: 0; Description: Rookie High translates the advantages of the Rookie office chair to standing table height. Pleasantly comfortable, it adapts quickly and easily to each user with the aid of minimal elements and functions. The ability to alternate between sitting and standing postures at office desks and in meetings ensures optimum ergonomics – and when it is the user that changes position, rather than the table top, the action is spontaneous and dynamic. The seat, backrest and steel foot ring are vertically adjustable, and the latter serves as a practical support when sitting or standing. This makes Rookie High an excellent choice for any environment in which people wish to engage at eye level, whether they are seated or not – for example in offices and meeting rooms or at touch-down workstations.; Designer: Konstantin Grcic; Manufacturer: Vitra; Model: Rookie High; OmniClass Number: 23.40.20.14.14.11; OmniClass Title: Chairs; ProductDatasheet: https://www.vitra.com/en-us/_storage/asset/2483518/storage/master/download/Factsheet%20Rookie%20Chair-EN.pdf; Type Name: Rookie High; URL: https://www.vitra.com/en-us/office/product/details/rookie-high
Type - Materials and Finishes(Type) - OfficeChairTertiaryMaterial: Basic dark
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; Category: Chairs; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Furniture_Office-Chairs_Vitra_Rookie_High; Features: Height adjustable in accordance with EN 16139.; Finish: Backrest: back made of polypropylene and back cushion of polyurethane foam. Back shell in soft grey or deep black; back cushion with fabric or leather cover stretched over padding. Backrest height adjustable up to 55 mm using a quick release lever. Seat: polypropylene shell in soft grey or deep black; polyurethane foam cushion; fabric or leather cover stretched over padding. Equipped as standard with seat height adjustment. Foot ring: equipped with height-adjustable steel foot ring, powder-coated in deep black with anti-skid finish, or chrome-plated. Base: five-star base made of polyamide in soft grey or deep black; reverse brake castors (Ø 60 mm) in basic dark.; Grade: n/a; ModelNumber: n/a; ModelReference: n/a; Name: Vitra_Rookie_High; ReplacementCost: n/a; Shape: Sculptured; Size: 680x680x965-1260 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Construction - HeightControl: 965 mm; TotalHeight: 965 mm
Dimensions - Area: 1.8744 m2; NominalHeight: 965 mm; Volume: 0.486457 m3
Materials and Finishes - OfficeChairMainMaterial: Sierra grey 19; OfficeChairSecondaryMaterial: 53 soft grey
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: Furniture_Office-Chairs_Vitra_Rookie_High: Rookie High; Family and Type: Furniture_Office-Chairs_Vitra_Rookie_High: Rookie High; InstallationDate: n/a; Material: Polypropylene, polyurethane, polyamide, steel & textile or leather.; SerialNumber: n/a; TagNumber: n/a; Type: Furniture_Office-Chairs_Vitra_Rookie_High: Rookie High; Type Id: Furniture_Office-Chairs_Vitra_Rookie_High: Rookie High; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
